# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Start;..\Library;..\User;..\System;..\Hardware\Sensor\DHT11;..\Hardware\Sensor\Light;..\Hardware\Actuator\Buzzer;..\Hardware\Display;..\Hardware\Communication\ESP8266;..\Hardware\Middlewares\Filter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Strat
    ../Start/: startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
  group Library
    ../Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/: Delay.c
  group Hardware
    ../Hardware/Sensor/DHT11/: DHT11.c
    ../Hardware/Sensor/Light/: light.c
    ../Hardware/Actuator/Buzzer/: Buzzer.c
    ../Hardware/Display/: OLED.c
    ../Hardware/Communication/ESP8266/: ESP8266.c
    ../Hardware/Middlewares/Filter/: Kalman.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/App/: app.c
